## firmware/fw_bitbox_v1/sdkconfig.defaults
```kconfig
CONFIG_SPIRAM=y
CONFIG_SPIRAM_MODE_AUTO=y
CONFIG_HEAP_ALLOC_CAPS_SPIRAM=y
CONFIG_SPIRAM_USE_MALLOC=y
```
